# Repository PVSSLR/Breadboard_Power_Supply

File README.md:

# Breakboard Power Supply

This project is a part of the course "Tech Explorations™ KiCad Like a Pro 2nd edition" and in this project we design a 
breadboard power supply(5V) using KiCad, which can be used with Arduino. I would like to thank Peter Dalmaris for making this wonderful course.

### Prerequisites
The prerequisites are given below
```
*KiCad
```
### Components
```
* 1x  Linear Regulator
* 4x Rectifier diodes
* 1x 470uF capacitor
* 2x Polarized capacitor
* 2x Led 
* 1x 560 ohms resistors 
* 1x Switch DPDT 
* 1x Connector 2x2 odd_even 
```

### PCB Layout

 ###  INSTRUCTION 
  1. Download the Gerber zip file
  2. To view the layouts you can go to [gerlook](http://gerblook.org/)
  3. To fabricate, you can upload the the gerber file to oshpark,pcbway

  ### NOTE 
  This is for Educational Purpose only

## KiCad design power_board.kicad_pcb

Board: 2 copper layers, 31.6 x 52.2 mm, 15 parts (0 on the bottom side), 8 nets.

Parts:
C1: CP; CP_Radial_D10.0mm_P5.00mm
C2: CP; CP_Radial_D6.3mm_P2.50mm
D1, D2, D3, D4: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
D5, D6: LED; LED_D5.0mm
J1: Barrel_Jack_Switch; BarrelJack_CUI_PJ-102AH_Horizontal
J2, J3: Conn_02x02_Odd_Even; PinHeader_2x02_P2.54mm_Vertical
R1, R2: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: SW_DPDT_x2; Switch_Slide_11.6x4mm_EG1218
U1: LM7805_TO220; TO-220-3_Vertical

Connections:
/BJ_pin1: D1.2, D2.1, J1.1
/BJ_pin2: D3.2, D4.1, J1.2
/V-: C1.2, C2.2, D2.2, D4.2, D5.1, D6.1, J2.3, J2.4, J3.3, J3.4, U1.2
/Vin: C1.1, D1.1, D3.1, U1.1
/Vout1: C2.1, R1.2, SW1.2, U1.3
/Vout2: J2.1, J2.2, J3.1, J3.2, R2.2, SW1.1
unnamed: D5.2, R1.1
unnamed: D6.2, R2.1
